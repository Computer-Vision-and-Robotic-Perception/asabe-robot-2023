Commit message: transmission problem solved

File: ROS/src/stepper_hardware/urdf/robot_description.urdf (robot description, URDF)
Before this commit: robot asabe_robot_description, 5 links, 4 joints
Joints:
- joint Joint_wheel1: axis 0 0 1 -> 0 0 -1
- joint Joint_wheel4: axis 0 0 1 -> 0 0 -1
